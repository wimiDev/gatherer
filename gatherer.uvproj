# Keil uVision project gatherer.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: gatherer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./code/: 15io.h DELAY.c DELAY.h global.h main.c NRF24L01.c NRF24L01.h schduler.c schduler.h uart.c uart.h gatherer.c gatherer.h
